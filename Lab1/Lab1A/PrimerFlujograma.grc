options:
  parameters:
    author: Juan Jose Morales - Fabian Yesid Moreno
    generate_options: qt_gui
    id: Lab_Comu_I
    output_language: python
    title: Primer Flujograma
  states: {}

blocks:
- name: amplitud
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '5'
    value: '0'
  states: {}
- name: amplitud
  id: variable
  parameters:
    value: '0.1'
  states: {state: disabled}
- name: frequency
  id: variable
  parameters:
    value: '1500'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: amplitud
    freq: frequency
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: float
    waveform: analog.GR_SQR_WAVE
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_throttle_0, '0']
- [blocks_throttle_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_throttle_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.5.1
